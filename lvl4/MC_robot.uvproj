# Keil uVision project MC_robot.uvproj, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: LPC1778 NXP
  cpu: IRAM(0x10000000-0x1000FFFF) IRAM2(0x20000000-0x20007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: p1
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x8000
  group Main Files
    ./: startup_LPC177x_8x.s core_cm3.c system_LPC177x_8x.c main.c
  group Output
    ./Utilities/: LED_P1_10_toggle.c LED_P1_10_toggle.h
    ./Output/: Motor.h Motor.c lcd_display.h lcd_display.c output.h output.c
  group Input
    ./input/: sensor.h sensor.c compass.h compass.c input.h input.c
  group Utilities
    ./Utilities/: delay.s delay.h
