# Keil uVision project MC_robot.uvproj, settings and files
target MC_Robot (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: LPC1778 NXP
  cpu: IRAM(0x10000000-0x1000FFFF) IRAM2(0x20000000-0x20007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: p1
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./: startup_LPC177x_8x.s core_cm3.c system_LPC177x_8x.c
  group Startup
    ./: main.c
  group Utilities
    ./Utilities/: delay.h delay.s LED_P1_10_toggle.c LED_P1_10_toggle.h
  group Input
    ./input/: input.h input.c sensor.h
    ./Input/: sensor.c
  group Output
    ./Output/: lcd_display.c lcd_display.h output.c output.h
